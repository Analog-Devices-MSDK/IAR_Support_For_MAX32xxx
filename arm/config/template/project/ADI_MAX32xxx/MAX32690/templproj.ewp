# IAR project templproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32690 Analog Devices MAX32690
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TARGET=MAX32690; TARGET_REV=0x4131; EXT_FLASH_MX25; FONT_LiberationSans12x12; FONT_LiberationSans16x16; FONT_LiberationSans19x19; FONT_LiberationSans24x24; FONT_LiberationSans28x28
  ICCARM.CCIncludePath2: $_MSDK_DIR_$\Libraries\PeriphDrivers\Include\MAX32690; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\ADC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\CAN; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\CTB; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\DMA; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\EMCC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\FLC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\GPIO; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\HPB; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\I2C; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\I2S; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\ICC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\LP; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\LPCMP; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SYS; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\OWM; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\PT; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\RTC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SEMA; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SPI; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SPIXF; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SPIXR; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\TMR; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\TRNG; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\UART; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\WDT; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\WUT; $_MSDK_DIR_$\Libraries\CMSIS\Device\Maxim\MAX32690\Include; $_MSDK_DIR_$\Libraries\CMSIS\5.9.0\Core\Include; $_MSDK_DIR_$\Libraries\Boards\MAX32690\$_MSDK_BOARD_$\Include; $_MSDK_DIR_$\Libraries\MiscDrivers\; $_MSDK_DIR_$\Libraries\MiscDrivers\LED; $_MSDK_DIR_$\Libraries\MiscDrivers\PushButton; $_MSDK_DIR_$\Libraries\MiscDrivers\ExtMemory; $_MSDK_DIR_$\Libraries\MiscDrivers\Display; $_MSDK_DIR_$\Libraries\MiscDrivers\Display\fonts; $_MSDK_DIR_$\Libraries\MAXUSB\include; $_MSDK_DIR_$\Libraries\MAXUSB\include\core; $_MSDK_DIR_$\Libraries\MAXUSB\include\core\musbhsfc; $_MSDK_DIR_$\Libraries\MAXUSB\include\enumerate; $_MSDK_DIR_$\Libraries\MAXUSB\include\devclass; $_MSDK_DIR_$\Libraries\MAXUSB\include\dbg_log
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TARGET=MAX32690; TARGET_REV=0x4131; EXT_FLASH_MX25; FONT_LiberationSans12x12; FONT_LiberationSans16x16; FONT_LiberationSans19x19; FONT_LiberationSans24x24; FONT_LiberationSans28x28; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: PeriphDrivers.out
  group (top)
    ./: main.c
  group Libraries/Boards
    $_MSDK_DIR_$/Libraries/Boards/MAX32690/$_MSDK_BOARD_$/Source/: board.c
  group Libraries/MAXUSB
    $_MSDK_DIR_$/Libraries/MAXUSB/src/devclass/: ccid.c cdc_acm.c fifo.c hid_kbd.c hid_raw.c msc.c
    $_MSDK_DIR_$/Libraries/MAXUSB/src/enumerate/: enumerate.c
    $_MSDK_DIR_$/Libraries/MAXUSB/src/core/musbhsfc/: usb.c
    $_MSDK_DIR_$/Libraries/MAXUSB/src/core/: usb_event.c
  group Libraries/MiscDrivers
    $_MSDK_DIR_$/Libraries/MiscDrivers/: stdio.c
  group Libraries/MiscDrivers/Display
    $_MSDK_DIR_$/Libraries/MiscDrivers/Display/: tft_st7735.c
  group Libraries/MiscDrivers/Display/Fonts
    $_MSDK_DIR_$/Libraries/MiscDrivers/Display/fonts/: LiberationSans12x12.c LiberationSans16x16.c LiberationSans19x19.c LiberationSans24x24.c LiberationSans28x28.c
  group Libraries/MiscDrivers/ExtMemory
    $_MSDK_DIR_$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group Libraries/MiscDrivers/LED
    $_MSDK_DIR_$/Libraries/MiscDrivers/LED/: led.c
  group Libraries/MiscDrivers/PushButton
    $_MSDK_DIR_$/Libraries/MiscDrivers/PushButton/: pb.c
  group Libraries/PeriphDrivers
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/ADC/: adc_me18.c adc_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/CAN/: can_me18.c can_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/CTB/: ctb_common.c ctb_me18.c ctb_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/DMA/: dma_me18.c dma_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/EMCC/: emcc_me18.c emcc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me18.c flc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me18.c gpio_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/HPB/: hpb_me18.c hpb_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/I2C/: i2c_me18.c i2c_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/I2S/: i2s_me18.c i2s_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/ICC/: icc_me18.c icc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/LP/: lp_me18.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/LPCMP/: lpcmp_me18.c lpcmp_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me18.c sys_me18.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/OWM/: owm_me18.c owm_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/PT/: pt_me18.c pt_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/RTC/: rtc_me18.c rtc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SEMA/: sema_me18.c sema_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SPI/: spi_me18.c spi_reva1.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SPIXF/: spixf_me18.c spixf_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SPIXR/: spixr_me18.c spixr_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me18.c tmr_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/TRNG/: trng_me18.c trng_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me18.c uart_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me18.c wdt_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/WUT/: wut_me18.c wut_reva.c
  group Libraries/Startup
    $_MSDK_DIR_$/Libraries/CMSIS/Device/Maxim/MAX32690/Source/IAR/: cmain.s low_level_init.c startup_max32690.s
    $_MSDK_DIR_$/Libraries/CMSIS/Device/Maxim/MAX32690/Source/: system_max32690.c
