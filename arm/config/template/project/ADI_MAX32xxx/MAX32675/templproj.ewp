# IAR project templproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32675 Analog Devices MAX32675
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TARGET=MAX32675; TARGET_REV=0x4131
  ICCARM.CCIncludePath2: $_MSDK_DIR_$\Libraries\PeriphDrivers\Include\MAX32675; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\AES; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\AFE; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\CRC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\DMA; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\FLC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\GPIO; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\I2C; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\I2S; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\ICC; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\LP; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\SPI; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\TRNG; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\TMR; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\UART; $_MSDK_DIR_$\Libraries\PeriphDrivers\Source\WDT; $_MSDK_DIR_$\Libraries\CMSIS\Device\Maxim\MAX32675\Include; $_MSDK_DIR_$\Libraries\CMSIS\5.9.0\Core\Include; $_MSDK_DIR_$\Libraries\Boards\MAX32675\$_MSDK_BOARD_$\Include; $_MSDK_DIR_$\Libraries\MiscDrivers\; $_MSDK_DIR_$\Libraries\MiscDrivers\LED; $_MSDK_DIR_$\Libraries\MiscDrivers\PushButton
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TARGET=MAX32675; TARGET_REV=0x4131; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: PeriphDrivers.out
  group (top)
    ./: main.c
  group Libraries/Boards
    $_MSDK_DIR_$/Libraries/Boards/MAX32675/$_MSDK_BOARD_$/Source/: board.c
  group Libraries/MiscDrivers
    $_MSDK_DIR_$/Libraries/MiscDrivers/: stdio.c
  group Libraries/MiscDrivers/LED
    $_MSDK_DIR_$/Libraries/MiscDrivers/LED/: led.c
  group Libraries/MiscDrivers/PushButton
    $_MSDK_DIR_$/Libraries/MiscDrivers/PushButton/: pb.c
  group Libraries/PeriphDrivers
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/AES/: aes_me15.c aes_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/AFE/: afe.c afe_gpio.c afe_timer.c hart_uart.c infoblock.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/CRC/: crc_me15.c crc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/DMA/: dma_me15.c dma_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me15.c flc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me16.c gpio_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/I2C/: i2c_me15.c i2c_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/I2S/: i2s_me15.c i2s_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me15.c icc_reva.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/LP/: lp_me15.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SPI/: spi_me15.c spi_reva1.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me16.c sys_me15.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/TRNG/: trng_me15.c trng_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me16.c tmr_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me16.c uart_revb.c
    $_MSDK_DIR_$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me15.c wdt_revb.c
  group Libraries/Startup
    $_MSDK_DIR_$/Libraries/CMSIS/Device/Maxim/MAX32675/Source/IAR/: cmain.s low_level_init.c startup_max32675.s
    $_MSDK_DIR_$/Libraries/CMSIS/Device/Maxim/MAX32675/Source/: system_max32675.c
